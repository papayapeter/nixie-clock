# Repository papayapeter/nixie-clock

File README.md:

# nixie-clock
a nixie clock built around 4 IN-2 tubes and an INS-1 dot

## KiCad design kicad/Nixie IN-2.kicad_pcb

Parts:
BT1: CR2032; BatteryHolder_Keystone_3002_1x2032
C1, C2, C3, C4, C5: 0.1µF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C6, C9: 0.1µF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7, C8: 6pF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1: D; D_SMA_Handsoldering
J1, J4: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
J2, J3: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J5: Barrel_Jack_Switch; PinHeader_1x03_P2.54mm_Vertical
Q1: MPSA42; TO-92_Inline_Wide
R1, R2, R3, R4: 13.33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 230k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 13.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R7, R8, R9: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
SW1, SW2, SW3: SW_SPST; PinHeader_1x02_P2.54mm_Vertical
TP1: 170V; TestPoint_THTPad_D2.5mm_Drill1.2mm
TP2: 12V; TestPoint_THTPad_D2.5mm_Drill1.2mm
TP3: 5V; TestPoint_THTPad_D2.5mm_Drill1.2mm
TP4: GND; TestPoint_THTPad_D2.5mm_Drill1.2mm
U1, U2, U3, U4, U5: TPIC6B595; SOIC-20W_7.5x12.8mm_P1.27mm
U6: SN74AHCT125; SO-14_3.9x8.65mm_P1.27mm
U7: Pico; RPi_Pico_SMD
U8: MCP7940N-xP; SOIC-8_3.9x4.9mm_P1.27mm
V1, V2, V3, V4: IN-2
V5: INS-1
VR1: NIXIE PSU; NIXIE-PSU-2
Y1: 32.768kHz; Crystal_DS26_D2.0mm_L6.0mm_Horizontal_SMT

Connections:
/3.3V: C9.1, R7.1, R8.1, R9.1, U7.36 (3V3), U8.8 (VCC)
/5V_1: C1.1, C2.1, C3.1, C4.1, C5.1, J2.1, TP3.1, U1.2 (VCC), U2.2 (VCC), U3.2 (VCC), U4.2 (VCC), U5.2 (VCC), VR1.5 (5V_OUT)
/5V_2: C6.2, D1.2 (A), J3.1, U6.14 (VCC)
/12V_1: J2.3, TP2.1, VR1.2 (12V_IN)
/12V_2: J3.3, J5.1
/170V: R1.1, R2.1, R3.1, R4.1, R5.1, TP1.1, VR1.3 (HV_OUT)
/CLOCK: J1.2, U1.13 (SRCK), U2.13 (SRCK), U3.13 (SRCK), U4.13 (SRCK), U5.13 (SRCK)
/DATA: J1.1, U1.3 (SERIN)
/DOT: J1.5, R6.2
/LATCH: J1.3, U1.12 (RCK), U2.12 (RCK), U3.12 (RCK), U4.12 (RCK), U5.12 (RCK)
/MCU_CLOCK: U6.9 (3A), U7.11 (GPIO8)
/MCU_DATA: U6.12 (4A), U7.12 (GPIO9)
/MCU_DOT: J4.5, U7.9 (GPIO6)
/MCU_LATCH: U6.5 (2A), U7.10 (GPIO7)
/MCU_OE: U6.2 (1A), U7.7 (GPIO5)
/MFP: R9.2, U7.25 (GPIO19), U8.7 (MFP)
/OE: J1.4, U1.9 (~G), U2.9 (~G), U3.9 (~G), U4.9 (~G), U5.9 (~G)
/SCL: R7.2, U7.26 (GPIO20), U8.6 (SCL)
/SDA: R8.2, U7.27 (GPIO21), U8.5 (SDA)
/SWITCH.1: SW1.1 (A), U7.31 (GPIO26_ADC0)
/SWITCH.2: SW2.1 (A), U7.32 (GPIO27_ADC1)
/SWITCH.3: SW3.1 (A), U7.34 (GPIO28_ADC2)
GND1: C1.2, C2.2, C3.2, C4.2, C5.2, J2.2, Q1.1 (E), TP4.1, U1.10 (GND), U1.11 (GND), U1.19 (GND), U2.10 (GND), U2.11 (GND), U2.19 (GND), U3.10 (GND), U3.11 (GND), U3.19 (GND), U4.10 (GND), U4.11 (GND), U4.19 (GND), U5.10 (GND), U5.11 (GND), U5.19 (GND), VR1.1 (GND), VR1.4 (GND)
GND2: BT1.2 (-), C6.1, C7.2, C8.2, C9.2, J3.2, J5.2, J5.3, SW1.2 (B), SW2.2 (B), SW3.2 (B), U6.1 (~1OE), U6.4 (~2OE), U6.7 (GND), U6.10 (~3OE), U6.13 (~4OE), U7.38 (GND), U8.4 (VSS)
unnamed: BT1.1 (+), U8.3 (VBAT)
unnamed: D1.1 (K), U7.39 (VSYS)
unnamed: J4.1, U6.11 (4Y)
unnamed: J4.2, U6.8 (3Y)
unnamed: J4.3, U6.6 (2Y)
unnamed: J4.4, U6.3 (1Y)
unnamed: Q1.2 (B), R6.1
unnamed: Q1.3 (C), V5.C
unnamed: R1.2, V1.A
unnamed: R2.2, V2.A
unnamed: R3.2, V3.A
unnamed: R4.2, V4.A
unnamed: R5.2, V5.A
unnamed: U1.4 (DRAIN0), V1.0
unnamed: U1.5 (DRAIN1), V1.1
unnamed: U1.6 (DRAIN2), V1.2
unnamed: U1.7 (DRAIN3), V1.3
unnamed: U1.14 (DRAIN4), V1.4
unnamed: U1.15 (DRAIN5), V1.5
unnamed: U1.16 (DRAIN6), V1.6
unnamed: U1.17 (DRAIN7), V1.7
unnamed: U1.18 (SEROUT), U2.3 (SERIN)
unnamed: U2.4 (DRAIN0), V1.8
unnamed: U2.5 (DRAIN1), V1.9
unnamed: U2.6 (DRAIN2), V2.0
unnamed: U2.7 (DRAIN3), V2.1
unnamed: U2.14 (DRAIN4), V2.2
unnamed: U2.15 (DRAIN5), V2.3
unnamed: U2.16 (DRAIN6), V2.4
unnamed: U2.17 (DRAIN7), V2.5
unnamed: U2.18 (SEROUT), U3.3 (SERIN)
unnamed: U3.4 (DRAIN0), V2.6
unnamed: U3.5 (DRAIN1), V2.7
unnamed: U3.6 (DRAIN2), V2.8
unnamed: U3.7 (DRAIN3), V2.9
unnamed: U3.14 (DRAIN4), V3.0
unnamed: U3.15 (DRAIN5), V3.1
unnamed: U3.16 (DRAIN6), V3.2
unnamed: U3.17 (DRAIN7), V3.3
unnamed: U3.18 (SEROUT), U4.3 (SERIN)
unnamed: U4.4 (DRAIN0), V3.4
unnamed: U4.5 (DRAIN1), V3.5
unnamed: U4.6 (DRAIN2), V3.6
unnamed: U4.7 (DRAIN3), V3.7
unnamed: U4.14 (DRAIN4), V3.8
unnamed: U4.15 (DRAIN5), V3.9
unnamed: U4.16 (DRAIN6), V4.0
unnamed: U4.17 (DRAIN7), V4.1
unnamed: U4.18 (SEROUT), U5.3 (SERIN)
unnamed: U5.4 (DRAIN0), V4.2
unnamed: U5.5 (DRAIN1), V4.3
unnamed: U5.6 (DRAIN2), V4.4
unnamed: U5.7 (DRAIN3), V4.5
unnamed: U5.14 (DRAIN4), V4.6
unnamed: U5.15 (DRAIN5), V4.7
unnamed: U5.16 (DRAIN6), V4.8
unnamed: U5.17 (DRAIN7), V4.9
unnamed: C8.1, U8.1 (X1), Y1.1
unnamed: C7.1, U8.2 (X2), Y1.2

Notes on the sheet:
SWITCHES
Anode Volate 150V Rated Current 1.5mA Max Current 2mA
13.5k for 3.3V 22k for 5V
RTC
MCU
TOP BOARD
Anode Volate 55V Rated Current 0.5mA
BOTTOM BOARD

Board: 2 copper layers, 113.0 x 88.3 mm, 50 parts (18 on the bottom side), 83 nets.

Other parts of the board:
mouse-bite-2.54mm-slot, mouse-bite-2.54mm-slot#2: VAL**; mouse-bite-2.54mm-slot

## Commit log

2019-07-09 start
2019-07-10 sourced clock Class out
2019-07-10 created clock library
2019-07-10 formatting
2019-07-10 changed constructor
2019-07-10 commented serial out
2019-08-15 added tests
2019-10-23 cleaned up
2020-08-03 added images
2020-08-03 changed directory
2023-09-19 new board

Notices in the files:
kicad/Nixie IN-2.kicad_pcb:
creativecommons.org
Licence: CC BY 4.0
